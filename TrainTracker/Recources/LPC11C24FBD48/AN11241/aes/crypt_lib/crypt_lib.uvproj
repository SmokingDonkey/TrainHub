# Keil uVision project crypt_lib.uvproj, settings and files
target CORTEX_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: crypt_lib_CM0 (library)
  c flags: Optim=4 OneElfS=1
  c define: TARGET_LPC11A
  c include: .\inc
  group src
    ./src/: crypt.c cypher.c decrypt.c init_crypt.c init_decrypt.c gen_aes128_expkey.c gen_aes192_expkey.c gen_aes256_expkey.c fips197_test_keys.c
target CORTEX_M3_M4 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: crypt_lib_CM3_CM4 (library)
  c flags: Optim=4 OneElfS=1
  c define: TARGET_LPC1769
  c include: .\inc; C:\dev\Keil_4_50\ARM\INC\NXP\LPC17xx
  asm include: C:\dev\Keil_4_50\ARM\INC\NXP\LPC17xx
target CORTEX_M0_TEST_MODE (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: crypt_lib_CM0_test_mode (library)
  c flags: Optim=4 OneElfS=1
  c define: TARGET_LPC11A TEST_MODE
  c include: .\inc
target CORTEX_M3_M4_TEST_MODE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: crypt_lib_CM3_CM4_test_mode (library)
  c flags: Optim=4 OneElfS=1
  c define: TEST_MODE TARGET_LPC1769
  c include: .\inc; C:\dev\Keil_4_50\ARM\INC\NXP\LPC17xx
  asm include: C:\dev\Keil_4_50\ARM\INC\NXP\LPC17xx
