# IAR project Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C14 NXP LPC11C14
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\Software\Master\inc; ..\..\..\Software\Drivers\inc; ..\..\..\Software\Drivers\inc\CANopen; ..\..\..\Software\Drivers\inc\UART; ..\..\..\Software\CMSIS\CM0\CoreSupport; ..\..\..\Software\CMSIS\CM0\DeviceSupport\NXP\LPC11xx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Master.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Master.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Application
    ../../../Software/Master/src/: CAN_Node_Def.c main.c
  group CMSIS
    ../../../Software/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../Software/CMSIS/CM0/DeviceSupport/NXP/LPC11xx/startup/iar/: startup_LPC11xx.s
    ../../../Software/CMSIS/CM0/DeviceSupport/NXP/LPC11xx/: system_LPC11xx.c
  group Drivers
    ../../../Software/Drivers/src/CANopen/: canopen_driver.c
    ../../../Software/Drivers/src/Retarget/IAR/: Retarget.c
    ../../../Software/Drivers/src/UART/: uart.c
