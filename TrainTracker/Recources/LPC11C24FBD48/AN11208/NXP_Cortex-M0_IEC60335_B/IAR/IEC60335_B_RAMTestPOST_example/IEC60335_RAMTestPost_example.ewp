# IAR project IEC60335_RAMTestPost_example.ewp, settings and files
configuration LPC1227 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1227 NXP LPC1227
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ICC_ARM__; LPC1227
  ICCARM.CCIncludePath2: ..\..\Core\CM0\CoreSupport\; ..\..\Core\CM0\DeviceSupport\NXP\LPC12xx\; ..\..\LPC12xx_Lib\inc; ..\..\IEC60335_B_libs\inc; config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: LPC1227
  AARM.AUserIncludes: ..\..\IEC60335_B_libs\inc; config
  OBJCOPY.OOCOutputFile: IEC60335_CPUregTestPost_example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\LPC1227_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LPC1114 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1114 NXP LPC1114
  ICCARM.CCDefines: __ICC_ARM__; LPC1114
  ICCARM.CCIncludePath2: ..\..\Core\CM0\CoreSupport\; ..\..\Core\CM0\DeviceSupport\NXP\LPC11xx\; ..\..\LPC11xx_Lib\inc; ..\..\IEC60335_B_libs\inc; config
  AARM.ADefines: LPC1114
  OBJCOPY.OOCOutputFile: IEC60335_RAMTestPost_example.srec
  ILINK.IlinkIcfFile: config\LPC1114_Flash.icf
  group (top)
    app/: main.c ramPostFailure_userHookFunction_IAR.s
    ./: README.txt
  group Config
    config/: IEC60335_B_UserData.c LPC1114_TargetConfig.c LPC1227_TargetConfig.c
  group Core
    ../../core/CM0/CoreSupport/: core_cm0.c
  group Device
    app/: startup_LPC11xx.s startup_LPC12xx.s
    ../../core/CM0/DeviceSupport/NXP/LPC11xx/: system_LPC11xx.c
    ../../core/CM0/DeviceSupport/NXP/LPC12xx/: system_LPC12xx.c
  group Drivers
    ../../LPC11xx_Lib/src/: lpc11xx_led.c
    ../../LPC12xx_Lib/src/: lpc12xx_led.c
  group IEC60335_B_libs
    ../../IEC60335_B_libs/src/: IEC60335_B_RAMTestPOST_IAR.s
