# Keil uVision project ClockTest_example.uvproj, settings and files
target LPC122x Flash (ARM-ADS)
  device: LPC1227/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: IEC60335_B_ClockTest +hex
  c flags: Optim=1
  c define: __CC_ARM__, LPC1227
  c include: .\.;.\config;..\..\LPC12xx_Lib\inc;..\..\core\CM0\CoreSupport;..\..\core\CM0\DeviceSupport\NXP\LPC12xx;..\..\IEC60335_B_libs\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Documentation
    ./: README.txt
  group Application
    ./app/: main.c rtc.c system_LPC122x.c
  group Core
    ../../core/CM0/CoreSupport/: core_cm0.c
    ../../core/CM0/DeviceSupport/NXP/LPC12xx/startup/arm/: startup_LPC12xx.s
  group IEC60335_B_Lib
    ../../IEC60335_B_libs/src/: IEC60335_B_ClockTest.c
  group Config
    ./config/: IEC60335_B_UserData.c LPC1227_TargetConfig.c
  group Drivers
    ../../LPC12xx_Lib/src/: lpc12xx_led.c
