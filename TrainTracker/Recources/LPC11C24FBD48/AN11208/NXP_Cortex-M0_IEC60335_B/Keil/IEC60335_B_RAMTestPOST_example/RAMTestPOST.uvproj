# Keil uVision project RAMTestPOST.uvproj, settings and files
target LPC1114 Flash (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NXP_CM0_ClassB +hex
  c flags: Optim=1 OneElfS=1
  c define: __CC_ARM__, LPC1114
  c include: ..\..\core\CM0\CoreSupport;..\..\core\CM0\DeviceSupport\NXP\LPC11xx;..\..\IEC60335_B_libs\inc;.\config;..\..\LPC11xx_Lib\inc
  asm include: ..\..\IEC60335_B_libs\inc;..\..\LPC11xx_Lib\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\config\LPC1114.sct
  group Documentation
    ./: README.txt
  group Application
    ./app/: main.c ramPostFailure_userHookFunction_ARM.s startup_LPC11xx_RAMTestPOST.s startup_LPC12xx_RAMTestPOST.s
  group Core
    ../../core/CM0/CoreSupport/: core_cm0.c
    ../../core/CM0/DeviceSupport/NXP/LPC11xx/: system_LPC11xx.c
    ../../core/CM0/DeviceSupport/NXP/LPC12xx/: system_LPC12xx.c
  group IEC60335_B_Lib
    ../../IEC60335_B_libs/src/: IEC60335_B_RAMTestPOST_ARM.s
  group Config
    ./config/: IEC60335_B_UserData.c LPC1114_TargetConfig.c LPC1227_TargetConfig.c LPC1114.sct LPC1227.sct
  group Drivers
    ../../LPC11xx_Lib/src/: lpc11xx_led.c
    ../../LPC12xx_Lib/src/: lpc12xx_led.c
target LPC1227 Flash (ARM-ADS)
  device: LPC1227/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NXP_CM0_ClassB +hex
  c flags: Optim=1 OneElfS=1
  c define: __CC_ARM__, LPC1227
  c include: ..\..\core\CM0\CoreSupport;..\..\core\CM0\DeviceSupport\NXP\LPC12xx;..\..\IEC60335_B_libs\inc;.\config;..\..\LPC12xx_Lib\inc
  asm include: ..\..\IEC60335_B_libs\inc;..\..\LPC12xx_Lib\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\config\LPC1227.sct
