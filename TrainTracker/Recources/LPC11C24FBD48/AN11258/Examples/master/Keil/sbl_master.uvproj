# Keil uVision project sbl_master.uvproj, settings and files
target LPC1700 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sbl_master +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0, __MCU_LPC17xx
  c include: ..\drivers\common;..\..\master;..\..\..\Core\Device\NXP\LPC17xx\Include;..\sbl;..\drivers\lpc17xx\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x7c00
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../../../Core/Device/NXP/LPC17xx/Source/Template/ARM/: startup_LPC17xx.s
    ../../../Core/Device/NXP/LPC11xx/Source/Templates/startup/arm/: startup_LPC11xx.s
  group CMSIS-CM3
    ../../../Core/Device/NXP/LPC17xx/Source/Template/: system_LPC17xx.c
  group CMSIS-CM0
    ../../../Core/Device/NXP/LPC11xx/Source/Templates/: system_LPC11xx.c
  group lpc17xx
    ../drivers/lpc17xx/source/: lpc17xx_uart.c lpc17xx_debug.c lpc17xx_i2c.c lpc17xx_sbl_i2c.c
  group lpc11xx
    ../drivers/lpc11xx/source/: LPC11xx_debug.c LPC11xx_uart.c LPC11xx_i2c.c LPC11xx_sbl_i2c.c
  group Main
    ../main/: master.c
  group SBL
    ../sbl/: sbl_master.c
target LPC1100 Flash (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: sbl_master +hex
  c flags: Optim=1 wLevel=2
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0, __MCU_LPC11xx
  c include: ..\drivers\common;..\..\master;..\..\..\Core\Device\NXP\LPC11xx\Include;..\sbl;..\drivers\lpc11xx\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x1c00
