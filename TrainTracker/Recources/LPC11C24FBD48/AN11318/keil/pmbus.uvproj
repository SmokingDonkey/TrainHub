# Keil uVision project pmbus.uvproj, settings and files
target Release (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: pmbus
  c flags: Optim=1
  c include: .;.\Common\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC13xx.s
    ./Common/src/: system_LPC13xx.c
  group Common
    ./Common/src/: gpio.c timer32.c i2c.c
  group src
    ./: app_pmbus.c
