<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IEC60335_FLASHTestPost_example.ewp</path>
  </project>
</workspace>


