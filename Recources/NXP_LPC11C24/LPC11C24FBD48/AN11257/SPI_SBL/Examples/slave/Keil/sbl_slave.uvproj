# Keil uVision project sbl_slave.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sbl_slave +hex
  AfterMake: fromelf.exe --bincombined --output  LPC17xx_Flash\sbl_slave.bin .\LPC17xx_Flash\sbl_slave.axf
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0,__MCU_LPC17xx
  c include: ..\..\slave;..\..\..\Core\Device\NXP\LPC17xx\Include;..\sbl;..\main;..\drivers\lpc17xx;..\drivers\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x6000
  memory RVCT10: RAM 0x2007c000 size 0x7000
  scatter file: .\lpc17xx_sbl_slave.sct
  group Startup
    ../../../Core/Device/NXP/LPC17xx/Source/Template/ARM/: startup_LPC17xx.s
    ../../../Core/Device/NXP/LPC11xx/Source/Templates/startup/arm/: startup_LPC11xx.s
  group CMSIS-CM3
    ../../../Core/Device/NXP/LPC17xx/Source/Template/: system_LPC17xx.c
  group CMSIS-CM0
    ../../../Core/Device/NXP/LPC11xx/Source/Templates/: system_LPC11xx.c
  group SBL
    ../sbl/: sbl_slave.c
    ../drivers/common/: iap.c
  group Main
    ../main/: slave.c
  group lpc17xx
    ../drivers/lpc17xx/: lpc17xx_spi.c lpc17xx_sbl_spi.c
  group lpc11xx
    ../drivers/lpc11xx/: LPC11xx_sbl_spi.c LPC11xx_ssp.c
target LPC1100 FLASH (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: sbl_slave +hex
  AfterMake: fromelf.exe --bincombined --output  LPC11xx_Flash\sbl_slave.bin .\LPC11xx_Flash\sbl_slave.axf
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0,__MCU_LPC11xx
  c include: ..\..\slave;..\..\..\Core\Device\NXP\LPC11xx\Include;..\sbl;..\main;..\drivers\lpc11xx;..\drivers\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\lpc11xx_sbl_slave.sct
