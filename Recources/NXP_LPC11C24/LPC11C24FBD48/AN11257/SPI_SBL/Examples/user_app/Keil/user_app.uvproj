# Keil uVision project user_app.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: user_app +hex
  AfterMake: fromelf.exe --bincombined --output  lpc17xx_Flash\user_app.bin .\lpc17xx_Flash\user_app.axf
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0,__MCU_LPC17xx
  c include: ..\..\user_app;..\..\..\Core\Device\NXP\LPC17xx\Include;..\drivers\common;..\drivers\lpc17xx\include;..\..\lpc17xx_slave;..\sbl
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x7f000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\lpc17xx_user_app.sct
  group Startup
    ../../../Core/Device/NXP/LPC17xx/Source/Template/ARM/: startup_LPC17xx.s
    ../../../Core/Device/NXP/LPC11xx/Source/Templates/startup/arm/: startup_LPC11xx.s
  group CMSIS-CM3
    ../../../Core/Device/NXP/LPC17xx/Source/Template/: system_LPC17xx.c
  group CMSIS-CM0
    ../../../Core/Device/NXP/LPC11xx/Source/Templates/: system_LPC11xx.c
  group Main
    ../main/: mcu_main_new.c
  group SBL
    ../drivers/common/: iap.c
    ../sbl/: sector0_program.c sbl_slave.c
  group LPC11xx
    ../drivers/lpc11xx/source/: LPC11xx_clkpwr.c LPC11xx_gpio.c LPC11xx_pinsel.c LPC11xx_sbl_spi.c LPC11xx_ssp.c
  group LPC17xx
    ../drivers/lpc17xx/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_spi.c lpc17xx_sbl_spi.c
target LPC1100 FLASH (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: user_app +hex
  AfterMake: fromelf.exe --bincombined --output  lpc11xx_Flash\user_app.bin .\lpc11xx_Flash\user_app.axf
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0,__MCU_LPC11xx
  c include: ..\..\user_app;..\..\..\Core\Device\NXP\LPC11xx\Include;..\..\lpc11xx_slave;..\drivers\common;..\drivers\lpc11xx\include;..\sbl
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\lpc11xx_user_app.sct
