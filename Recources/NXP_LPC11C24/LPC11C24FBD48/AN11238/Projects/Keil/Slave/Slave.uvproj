# Keil uVision project Slave.uvproj, settings and files
target Slave (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Slave +hex
  c flags: Optim=1
  c include: ..\..\..\Software\Slave\inc;..\..\..\Software\Drivers\inc;..\..\..\Software\Drivers\inc\CANopen;..\..\..\Software\Drivers\inc\UART;..\..\..\Software\CMSIS\CM0\CoreSupport;..\..\..\Software\CMSIS\CM0\DeviceSupport\NXP\LPC11xx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x50
  memory RVCT10: RAM 0x10000100 size 0x1f00
  group Application
    ../../../Software/Slave/src/: CAN_Node_Def.c main.c
  group CMSIS
    ../../../Software/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../Software/CMSIS/CM0/DeviceSupport/NXP/LPC11xx/: system_LPC11xx.c
    ../../../Software/CMSIS/CM0/DeviceSupport/NXP/LPC11xx/startup/arm/: startup_LPC11xx.s
  group Drivers
    ../../../Software/Drivers/src/CANopen/: canopen_driver.c
    ../../../Software/Drivers/src/Retarget/Keil/: Retarget.c
    ../../../Software/Drivers/src/UART/: uart.c
