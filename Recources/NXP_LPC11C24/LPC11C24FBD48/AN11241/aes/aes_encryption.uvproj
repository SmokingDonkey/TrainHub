# Keil uVision project aes_encryption.uvproj, settings and files
target LPC11A14 (ARM-ADS)
  device: LPC11A14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: encryption_test_LPC11A
  c flags: OneElfS=1
  c define: TARGET_LPC11A
  c include: .\crypt_lib\inc;.\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group startup
    ./platform/: system_LPC11Axx.c startup_LPC11Axx.s system_LPC17xx.c startup_LPC17xx.s
  group application
    ./application/: main.c
    ./: abstract.txt
  group crypt_lib
    ./crypt_lib/libs/: crypt_lib_CM0.lib crypt_lib_CM0_test_mode.lib crypt_lib_CM3_CM4.lib crypt_lib_CM3_CM4_test_mode.lib
target LPC1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: encryption_test_LPC1769
  c flags: OneElfS=1
  c define: TARGET_LPC1769
  c include: .\crypt_lib\inc;.\platform;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC11A14_TEST_MODE (ARM-ADS)
  device: LPC11A14/301 NXP (founded by Philips)
  cpu: as above
  output: encryption_test_dbg_LPC11A
  c flags: OneElfS=1
  c define: TEST_MODE TARGET_LPC11A
  c include: .\crypt_lib\inc;.\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
target LPC1769_TEST_MODE (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: as above
  output: encryption_test_LPC1769
  c flags: OneElfS=1
  c define: TARGET_LPC1769 TEST_MODE
  c include: .\crypt_lib\inc;.\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
